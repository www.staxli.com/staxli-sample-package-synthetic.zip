Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: job_01a17b41b4a27036a391df8d5c6d0d19.ifc
Time: 2000-01-01T00:00:00
Written by: Staxli worker
Made in: Staxli worker

# IfcBuildingStorey, Steel
In: Building
Elevation: 0 mm

# IfcBeam: RAFTER (6)
In: Steel
Description: 250UB31.4; PredefinedType: BEAM; Material: 300PLUS
Detailing_Part - Finish: PRIMED AND PAINTED; Grade: 300PLUS; HoldForRfi: no; Length: 5857.1 mm; Mark: m1004; Mass: 184.376 kg
Name | Key
m1004 | mem_R1_A1
m1004 | mem_R1_A2
m1004 | mem_R1_A3
m1004 | mem_R1_B1-A1
m1004 | mem_R1_B2-A2
m1004 | mem_R1_B3-A3

# IfcColumn: COLUMN (6)
In: Steel
Description: 310UB40.4; PredefinedType: COLUMN; Material: 300PLUS
Detailing_Part - Finish: PRIMED AND PAINTED; Grade: 300PLUS; HoldForRfi: no; Length: 6114.13 mm; Mark: m1003; Mass: 250.062 kg
Name | Key
m1003 | mem_C1_A1
m1003 | mem_C1_A2
m1003 | mem_C1_A3
m1003 | mem_C1_B1
m1003 | mem_C1_B2
m1003 | mem_C1_B3

# IfcElementAssembly (12)
In: Steel
AssemblyPlace: FACTORY
Name
6 x C2
6 x R2

# IfcFastener (42)
In: Steel
PredefinedType: WELD
Detailing_Weld - AllRound: no; Size: 6 mm; Type: FILLET
Name | PartA | PartB
node_A1_base.w_base_plate | mem_C1_A1 | node_A1_base.base_plate
node_A2_base.w_base_plate | mem_C1_A2 | node_A2_base.base_plate
node_A3_base.w_base_plate | mem_C1_A3 | node_A3_base.base_plate
node_B1_base.w_base_plate | mem_C1_B1 | node_B1_base.base_plate
node_B2_base.w_base_plate | mem_C1_B2 | node_B2_base.base_plate
node_B3_base.w_base_plate | mem_C1_B3 | node_B3_base.base_plate
node_A1_apex.w_end_plate_1 | mem_R1_A1 | node_A1_apex.end_plate_1
node_A1_knee.w_haunch_flange_end_plate | node_A1_knee.haunch_flange | node_A1_knee.end_plate
node_A1_knee.w_haunch_flange_web | node_A1_knee.haunch_flange | node_A1_knee.haunch_web
node_A1_knee.w_haunch_web_end_plate | node_A1_knee.haunch_web | node_A1_knee.end_plate
node_A1_knee.w_haunch_web_rafter | node_A1_knee.haunch_web | mem_R1_A1
node_A1_knee.w_rafter_end_plate | mem_R1_A1 | node_A1_knee.end_plate
node_A2_apex.w_end_plate_1 | mem_R1_A2 | node_A2_apex.end_plate_1
node_A2_knee.w_haunch_flange_end_plate | node_A2_knee.haunch_flange | node_A2_knee.end_plate
node_A2_knee.w_haunch_flange_web | node_A2_knee.haunch_flange | node_A2_knee.haunch_web
node_A2_knee.w_haunch_web_end_plate | node_A2_knee.haunch_web | node_A2_knee.end_plate
node_A2_knee.w_haunch_web_rafter | node_A2_knee.haunch_web | mem_R1_A2
node_A2_knee.w_rafter_end_plate | mem_R1_A2 | node_A2_knee.end_plate
node_A3_apex.w_end_plate_1 | mem_R1_A3 | node_A3_apex.end_plate_1
node_A3_knee.w_haunch_flange_end_plate | node_A3_knee.haunch_flange | node_A3_knee.end_plate
node_A3_knee.w_haunch_flange_web | node_A3_knee.haunch_flange | node_A3_knee.haunch_web
node_A3_knee.w_haunch_web_end_plate | node_A3_knee.haunch_web | node_A3_knee.end_plate
node_A3_knee.w_haunch_web_rafter | node_A3_knee.haunch_web | mem_R1_A3
node_A3_knee.w_rafter_end_plate | mem_R1_A3 | node_A3_knee.end_plate
node_A1_apex.w_end_plate_2 | mem_R1_B1-A1 | node_A1_apex.end_plate_2
node_B1_knee.w_haunch_flange_end_plate | node_B1_knee.haunch_flange | node_B1_knee.end_plate
node_B1_knee.w_haunch_flange_web | node_B1_knee.haunch_flange | node_B1_knee.haunch_web
node_B1_knee.w_haunch_web_end_plate | node_B1_knee.haunch_web | node_B1_knee.end_plate
node_B1_knee.w_haunch_web_rafter | node_B1_knee.haunch_web | mem_R1_B1-A1
node_B1_knee.w_rafter_end_plate | mem_R1_B1-A1 | node_B1_knee.end_plate
node_A2_apex.w_end_plate_2 | mem_R1_B2-A2 | node_A2_apex.end_plate_2
node_B2_knee.w_haunch_flange_end_plate | node_B2_knee.haunch_flange | node_B2_knee.end_plate
node_B2_knee.w_haunch_flange_web | node_B2_knee.haunch_flange | node_B2_knee.haunch_web
node_B2_knee.w_haunch_web_end_plate | node_B2_knee.haunch_web | node_B2_knee.end_plate
node_B2_knee.w_haunch_web_rafter | node_B2_knee.haunch_web | mem_R1_B2-A2
node_B2_knee.w_rafter_end_plate | mem_R1_B2-A2 | node_B2_knee.end_plate
node_A3_apex.w_end_plate_2 | mem_R1_B3-A3 | node_A3_apex.end_plate_2
node_B3_knee.w_haunch_flange_end_plate | node_B3_knee.haunch_flange | node_B3_knee.end_plate
node_B3_knee.w_haunch_flange_web | node_B3_knee.haunch_flange | node_B3_knee.haunch_web
node_B3_knee.w_haunch_web_end_plate | node_B3_knee.haunch_web | node_B3_knee.end_plate
node_B3_knee.w_haunch_web_rafter | node_B3_knee.haunch_web | mem_R1_B3-A3
node_B3_knee.w_rafter_end_plate | mem_R1_B3-A3 | node_B3_knee.end_plate

# IfcMechanicalFastener (96)
In: Steel
PredefinedType: BOLT
Name | NominalDiameter (mm)
48 x M20 8.8 | 20
48 x M24 8.8 | 24

# IfcOpeningElement (180)
In: Steel
PredefinedType: OPENING
Name
168 x HOLE
12 x END_CUT

# IfcPlate: BASE_PLATE (6)
In: Steel
Description: PL20; Material: 250
Detailing_Part - Finish: PRIMED AND PAINTED; Grade: 250; HoldForRfi: no; Length: 400 mm; Mark: p102; Mass: 15.7 kg
Name | Key
p102 | node_A1_base.base_plate
p102 | node_A2_base.base_plate
p102 | node_A3_base.base_plate
p102 | node_B1_base.base_plate
p102 | node_B2_base.base_plate
p102 | node_B3_base.base_plate

# IfcPlate: END_PLATE (12)
In: Steel
Material: 250
Detailing_Part - Finish: PRIMED AND PAINTED; Grade: 250; HoldForRfi: no; Length: 180 mm
Name | Description | Key | Mark | Mass (kg)
p101 | PL20 | node_A1_apex.end_plate_1 | p101 | 9.18
p101 | PL20 | node_A1_apex.end_plate_2 | p101 | 9.18
p103 | PL25 | node_A1_knee.end_plate | p103 | 21.738
p101 | PL20 | node_A2_apex.end_plate_1 | p101 | 9.18
p101 | PL20 | node_A2_apex.end_plate_2 | p101 | 9.18
p103 | PL25 | node_A2_knee.end_plate | p103 | 21.738
p101 | PL20 | node_A3_apex.end_plate_1 | p101 | 9.18
p101 | PL20 | node_A3_apex.end_plate_2 | p101 | 9.18
p103 | PL25 | node_A3_knee.end_plate | p103 | 21.738
p103 | PL25 | node_B1_knee.end_plate | p103 | 21.738
p103 | PL25 | node_B2_knee.end_plate | p103 | 21.738
p103 | PL25 | node_B3_knee.end_plate | p103 | 21.738

# IfcPlate: HAUNCH_FLANGE (6)
In: Steel
Description: PL12; Material: 250
Detailing_Part - Finish: PRIMED AND PAINTED; Grade: 250; HoldForRfi: no; Length: 1566.05 mm; Mark: p104; Mass: 25.079 kg
Name | Key
p104 | node_A1_knee.haunch_flange
p104 | node_A2_knee.haunch_flange
p104 | node_A3_knee.haunch_flange
p104 | node_B1_knee.haunch_flange
p104 | node_B2_knee.haunch_flange
p104 | node_B3_knee.haunch_flange

# IfcPlate: HAUNCH_WEB (6)
In: Steel
Description: PL8; Material: 250
Detailing_Part - Finish: PRIMED AND PAINTED; Grade: 250; HoldForRfi: no; Length: 1500 mm; Mark: p105; Mass: 14.13 kg
Name | Key
p105 | node_A1_knee.haunch_web
p105 | node_A2_knee.haunch_web
p105 | node_A3_knee.haunch_web
p105 | node_B1_knee.haunch_web
p105 | node_B2_knee.haunch_web
p105 | node_B3_knee.haunch_web
